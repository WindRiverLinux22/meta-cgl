## meta-cgl-common/conf/distro/include/cgl_common_security_flags.inc
```bitbake
SECURITY_CFLAGS:pn-ocfs2-tools = "${SECURITY_NOPIE_CFLAGS}"
SECURITY_LDFLAGS:pn-ocfs2-tools = ""
```
